DESCRIPTION = "HDMI image definition for Avnet boards"
LICENSE = "MIT"

require avnet-image-hdmi.inc

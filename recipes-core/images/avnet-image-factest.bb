DESCRIPTION = "Factest image definition for Avnet boards"
LICENSE = "MIT"

require avnet-image-factest.inc


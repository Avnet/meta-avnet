ULTRA96_STARTUP_PAGES_PACKAGES_remove = " \
	chromium-x11 \
	"

RDEPENDS_${PN}_remove = "\
    dnndk \
"

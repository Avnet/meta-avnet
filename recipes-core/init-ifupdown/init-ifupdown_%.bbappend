FILESEXTRAPATHS_prepend_ultra96v2 := "${THISDIR}/files:"

INITSCRIPT_PARAMS_ultra96v2 = "start 03 2 3 4 5 . stop 80 0 6 1 ."
